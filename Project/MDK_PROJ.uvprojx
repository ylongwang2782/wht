# Keil uVision project MDK_PROJ.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F470VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F4_pro +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: GD32F470,MASTER
  c include: ..\Source\BSP\inc;..\Source\Config;..\Source\Core;..\Source\Drivers\CMSIS;..\Source\Drivers\CMSIS\GD\GD32F4xx\Include;..\Source\Drivers\GD32F4xx_standard_peripheral\Include;..\Source\Middlewares\FreeRTOS\Source\include;..\Source\Retarget\inc;..\Source\Middlewares\FreeRTOS\Source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ../Source/Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Source/Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group BSP
    ../Source/BSP/src/: bsp_led.cpp bsp_log.cpp bsp_uart.cpp bsp_uid.cpp
  group Core
    ../Source/Core/: freertos.c gd32f4xx_it.c main.cpp chronolink.cpp conduction.cpp
    ../Source/Core/slave/: slave_mode.cpp
    ../Source/Core/master/: master_mode.cpp
  group Drivers/GD32F4xx_standard_peripheral
    ../Source/Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group FreeRTOS
    ../Source/Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Source/Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Source/Middlewares/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
